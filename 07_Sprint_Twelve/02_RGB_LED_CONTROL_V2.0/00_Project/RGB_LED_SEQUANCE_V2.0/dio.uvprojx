# Keil uVision project dio.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: dio_prog.c dio_config.c dio_config.h dio_interface.h dio_private.h std_types.h bit_math.h main.c led_prog.c led_config.c led_config.h led_interface.h PUSH_BTN_prog.c PUSH_BTN_config.c PUSH_BTN_interface.h PUSH_BTN_config.h app.c app.h systick_prog.c systick_private.h systick_interface.h systick_config.h systick_config.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
