# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group GPIO
    ../: BIT_MATH.h Mcu_Hw.h port.h port_lcfg.h STD_TYPES.h main.c port.c port_lcfg.c BUTTON_config.h BUTTON_interface.h BUTTON_config.c BUTTON_prog.c led_config.c led_prog.c led_config.h led_interface.h app.h app.c
    ./: system_tick.c system_tick.h systemtick_config.h systemtick_config.c GPT_lcfg.h GPT_lcfg.c GPT.c GPT.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
